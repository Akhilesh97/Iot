# Keil uVision project final.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: NUC140VE3AN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: final
  c flags: Optim=1
  c include: ..\..\..\CMSIS\CM0\CoreSupport;..\..\..\CMSIS\CM0\DeviceSupport;..\..\Include;..\..\Include\Driver;..\..\Include\NUC1xx-LB_002
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source Group 1
    ./: startup_NUC1xx.s q_11_final.c
    ../../Src/Driver/: DrvGPIO.c DrvSYS.c DrvUART.c DrvADC.c DrvRTC.c
    ../../../CMSIS/CM0/CoreSupport/: core_cm0.c
    ../../../CMSIS/CM0/DeviceSupport/Nuvoton/NUC1xx/: system_NUC1xx.c
    ../../Src/NUC1xx-LB_002/: LCD_Driver.c Ascii_Table.C Seven_Segment.c
    ../../Include/Driver/: DrvRTC.h
